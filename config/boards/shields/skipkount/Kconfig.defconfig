## config/boards/shields/skipkount/Kconfig.defconfig
```kconfig
if SHIELD_SKIPKOUNT

config ZMK_KEYBOARD_NAME
  default "SkipKount_AUS01"

endif
```
